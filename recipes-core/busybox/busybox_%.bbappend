SRC_URI += "file://rsyocto_default_busyBox_1.31.1.conf;subdir=busybox-1.31.1"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

